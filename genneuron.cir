***    THIS IS AN AUTOGENERATED FILE   ***
.include LSmitll_bufft_v1p5.cir
.include LSmitll_PTLRX_SFQDC_v1p5.cir
.include LSmitll_SPLITT_v1p5.cir
.INCLUDE LSMITLL_JTLT_V1P5.cir
.INCLUDE LSMITLL_MERGET_V1P5.cir
.include storeedit.cir
.INCLUDE COMPONENTSEDIT.cir
.INCLUDE COMP3.cir
.INCLUDE COMP4.cir
.INCLUDE COMP5.cir
.INCLUDE COMP6.cir
.include conv.cir
.INCLUDE synapsenext2.cir
.INCLUDE DCPULSER.cir
.INCLUDE MULTISPLIT.cir
.include transmit.cir
.INCLUDE DELAY7.cir
.INCLUDE AND.cir
.INCLUDE AND3.cir
.INCLUDE OR3.cir
.include PERCEPTRON.cir
.include PERCEPTRON2.cir
.include CONVINTERFACE.cir
.include NEURONLETTERS.cir
.tran 1ps 2.301e-08 0ps 1p
***    INPUTS  ***
IIN1 0 IIN1x PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00
+ 1.3550e-09 1.0000e-03 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03
+ 2.4100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00
+ 4.3550e-09 1.0000e-03 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03
+ 5.4100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00
+ 7.3550e-09 1.0000e-03 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.1500e-09 0.0000e+00
+ 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00
+ 9.7550e-09 1.0000e-03 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0550e-08 0.0000e+00
+ 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2350e-08 0.0000e+00 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03
+ 1.2410e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03
+ 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5350e-08 0.0000e+00 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03
+ 1.5410e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03
+ 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8350e-08 0.0000e+00 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03
+ 1.8410e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03
+ 1.9210e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0750e-08 0.0000e+00 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03
+ 2.0810e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03
+ 2.1610e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN2 0 IIN2x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 5.5000e-10 0.0000e+00 5.5500e-10 1.0000e-03
+ 6.0500e-10 1.0000e-03 6.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.5500e-09 0.0000e+00
+ 1.5550e-09 1.0000e-03 1.6050e-09 1.0000e-03 1.6100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.5500e-09 0.0000e+00 2.5550e-09 1.0000e-03 2.6050e-09 1.0000e-03
+ 2.6100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.5500e-09 0.0000e+00 3.5550e-09 1.0000e-03
+ 3.6050e-09 1.0000e-03 3.6100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.5500e-09 0.0000e+00
+ 4.5550e-09 1.0000e-03 4.6050e-09 1.0000e-03 4.6100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.5500e-09 0.0000e+00 5.5550e-09 1.0000e-03 5.6050e-09 1.0000e-03
+ 5.6100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.5500e-09 0.0000e+00 6.5550e-09 1.0000e-03
+ 6.6050e-09 1.0000e-03 6.6100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.5500e-09 0.0000e+00
+ 7.5550e-09 1.0000e-03 7.6050e-09 1.0000e-03 7.6100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.3500e-09 0.0000e+00
+ 8.3550e-09 1.0000e-03 8.4050e-09 1.0000e-03 8.4100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 9.1500e-09 0.0000e+00
+ 9.1550e-09 1.0000e-03 9.2050e-09 1.0000e-03 9.2100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.9500e-09 0.0000e+00
+ 9.9550e-09 1.0000e-03 1.0005e-08 1.0000e-03 1.0010e-08 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0750e-08 0.0000e+00
+ 1.0755e-08 1.0000e-03 1.0805e-08 1.0000e-03 1.0810e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1550e-08 0.0000e+00
+ 1.1555e-08 1.0000e-03 1.1605e-08 1.0000e-03 1.1610e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2550e-08 0.0000e+00 1.2555e-08 1.0000e-03 1.2605e-08 1.0000e-03
+ 1.2610e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3550e-08 0.0000e+00 1.3555e-08 1.0000e-03
+ 1.3605e-08 1.0000e-03 1.3610e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4550e-08 0.0000e+00
+ 1.4555e-08 1.0000e-03 1.4605e-08 1.0000e-03 1.4610e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5550e-08 0.0000e+00 1.5555e-08 1.0000e-03 1.5605e-08 1.0000e-03
+ 1.5610e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6550e-08 0.0000e+00 1.6555e-08 1.0000e-03
+ 1.6605e-08 1.0000e-03 1.6610e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7550e-08 0.0000e+00
+ 1.7555e-08 1.0000e-03 1.7605e-08 1.0000e-03 1.7610e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8550e-08 0.0000e+00 1.8555e-08 1.0000e-03 1.8605e-08 1.0000e-03
+ 1.8610e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9350e-08 0.0000e+00 1.9355e-08 1.0000e-03 1.9405e-08 1.0000e-03
+ 1.9410e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 2.0150e-08 0.0000e+00 2.0155e-08 1.0000e-03 2.0205e-08 1.0000e-03
+ 2.0210e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0950e-08 0.0000e+00 2.0955e-08 1.0000e-03 2.1005e-08 1.0000e-03
+ 2.1010e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1750e-08 0.0000e+00 2.1755e-08 1.0000e-03 2.1805e-08 1.0000e-03
+ 2.1810e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN3 0 IIN3x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00
+ 1.3550e-09 1.0000e-03 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03
+ 2.4100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00
+ 4.3550e-09 1.0000e-03 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03
+ 5.4100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00
+ 7.3550e-09 1.0000e-03 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.1500e-09 0.0000e+00
+ 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00
+ 9.7550e-09 1.0000e-03 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0550e-08 0.0000e+00
+ 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2350e-08 0.0000e+00 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03
+ 1.2410e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03
+ 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5350e-08 0.0000e+00 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03
+ 1.5410e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03
+ 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8350e-08 0.0000e+00 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03
+ 1.8410e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03
+ 1.9210e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0750e-08 0.0000e+00 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03
+ 2.0810e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03
+ 2.1610e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN4 0 IIN4x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00
+ 1.3550e-09 1.0000e-03 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03
+ 2.4100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00
+ 4.3550e-09 1.0000e-03 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03
+ 5.4100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00
+ 7.3550e-09 1.0000e-03 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.1500e-09 0.0000e+00
+ 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00
+ 9.7550e-09 1.0000e-03 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0550e-08 0.0000e+00
+ 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2350e-08 0.0000e+00 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03
+ 1.2410e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03
+ 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5350e-08 0.0000e+00 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03
+ 1.5410e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03
+ 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8350e-08 0.0000e+00 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03
+ 1.8410e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03
+ 1.9210e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0750e-08 0.0000e+00 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03
+ 2.0810e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03
+ 2.1610e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN5 0 IIN5x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 5.5000e-10 0.0000e+00 5.5500e-10 1.0000e-03
+ 6.0500e-10 1.0000e-03 6.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03 1.2050e-09 1.0000e-03
+ 1.2100e-09 0.0000e+00 1.5500e-09 0.0000e+00 1.5550e-09 1.0000e-03
+ 1.6050e-09 1.0000e-03 1.6100e-09 0.0000e+00 1.7500e-09 0.0000e+00
+ 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03 1.8100e-09 0.0000e+00
+ 2.1500e-09 0.0000e+00 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03
+ 2.2100e-09 0.0000e+00 2.5500e-09 0.0000e+00 2.5550e-09 1.0000e-03
+ 2.6050e-09 1.0000e-03 2.6100e-09 0.0000e+00 2.7500e-09 0.0000e+00
+ 2.7550e-09 1.0000e-03 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.5500e-09 0.0000e+00 3.5550e-09 1.0000e-03
+ 3.6050e-09 1.0000e-03 3.6100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03 4.2050e-09 1.0000e-03
+ 4.2100e-09 0.0000e+00 4.5500e-09 0.0000e+00 4.5550e-09 1.0000e-03
+ 4.6050e-09 1.0000e-03 4.6100e-09 0.0000e+00 4.7500e-09 0.0000e+00
+ 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03 4.8100e-09 0.0000e+00
+ 5.1500e-09 0.0000e+00 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03
+ 5.2100e-09 0.0000e+00 5.5500e-09 0.0000e+00 5.5550e-09 1.0000e-03
+ 5.6050e-09 1.0000e-03 5.6100e-09 0.0000e+00 5.7500e-09 0.0000e+00
+ 5.7550e-09 1.0000e-03 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.5500e-09 0.0000e+00 6.5550e-09 1.0000e-03
+ 6.6050e-09 1.0000e-03 6.6100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03 7.2050e-09 1.0000e-03
+ 7.2100e-09 0.0000e+00 7.5500e-09 0.0000e+00 7.5550e-09 1.0000e-03
+ 7.6050e-09 1.0000e-03 7.6100e-09 0.0000e+00 7.7500e-09 0.0000e+00
+ 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03 7.8100e-09 0.0000e+00
+ 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03 8.0050e-09 1.0000e-03
+ 8.0100e-09 0.0000e+00 8.3500e-09 0.0000e+00 8.3550e-09 1.0000e-03
+ 8.4050e-09 1.0000e-03 8.4100e-09 0.0000e+00 8.5500e-09 0.0000e+00
+ 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03 8.6100e-09 0.0000e+00
+ 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03 8.8050e-09 1.0000e-03
+ 8.8100e-09 0.0000e+00 9.1500e-09 0.0000e+00 9.1550e-09 1.0000e-03
+ 9.2050e-09 1.0000e-03 9.2100e-09 0.0000e+00 9.3500e-09 0.0000e+00
+ 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03 9.4100e-09 0.0000e+00
+ 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03 9.6050e-09 1.0000e-03
+ 9.6100e-09 0.0000e+00 9.9500e-09 0.0000e+00 9.9550e-09 1.0000e-03
+ 1.0005e-08 1.0000e-03 1.0010e-08 0.0000e+00 1.0150e-08 0.0000e+00
+ 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03 1.0210e-08 0.0000e+00
+ 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03 1.0405e-08 1.0000e-03
+ 1.0410e-08 0.0000e+00 1.0750e-08 0.0000e+00 1.0755e-08 1.0000e-03
+ 1.0805e-08 1.0000e-03 1.0810e-08 0.0000e+00 1.0950e-08 0.0000e+00
+ 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03 1.1010e-08 0.0000e+00
+ 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03 1.1205e-08 1.0000e-03
+ 1.1210e-08 0.0000e+00 1.1550e-08 0.0000e+00 1.1555e-08 1.0000e-03
+ 1.1605e-08 1.0000e-03 1.1610e-08 0.0000e+00 1.1750e-08 0.0000e+00
+ 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03 1.1810e-08 0.0000e+00
+ 1.2150e-08 0.0000e+00 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03
+ 1.2210e-08 0.0000e+00 1.2550e-08 0.0000e+00 1.2555e-08 1.0000e-03
+ 1.2605e-08 1.0000e-03 1.2610e-08 0.0000e+00 1.2750e-08 0.0000e+00
+ 1.2755e-08 1.0000e-03 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3550e-08 0.0000e+00 1.3555e-08 1.0000e-03
+ 1.3605e-08 1.0000e-03 1.3610e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03 1.4205e-08 1.0000e-03
+ 1.4210e-08 0.0000e+00 1.4550e-08 0.0000e+00 1.4555e-08 1.0000e-03
+ 1.4605e-08 1.0000e-03 1.4610e-08 0.0000e+00 1.4750e-08 0.0000e+00
+ 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03 1.4810e-08 0.0000e+00
+ 1.5150e-08 0.0000e+00 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03
+ 1.5210e-08 0.0000e+00 1.5550e-08 0.0000e+00 1.5555e-08 1.0000e-03
+ 1.5605e-08 1.0000e-03 1.5610e-08 0.0000e+00 1.5750e-08 0.0000e+00
+ 1.5755e-08 1.0000e-03 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6550e-08 0.0000e+00 1.6555e-08 1.0000e-03
+ 1.6605e-08 1.0000e-03 1.6610e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03 1.7205e-08 1.0000e-03
+ 1.7210e-08 0.0000e+00 1.7550e-08 0.0000e+00 1.7555e-08 1.0000e-03
+ 1.7605e-08 1.0000e-03 1.7610e-08 0.0000e+00 1.7750e-08 0.0000e+00
+ 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03 1.7810e-08 0.0000e+00
+ 1.8150e-08 0.0000e+00 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03
+ 1.8210e-08 0.0000e+00 1.8550e-08 0.0000e+00 1.8555e-08 1.0000e-03
+ 1.8605e-08 1.0000e-03 1.8610e-08 0.0000e+00 1.8750e-08 0.0000e+00
+ 1.8755e-08 1.0000e-03 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00
+ 1.8950e-08 0.0000e+00 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03
+ 1.9010e-08 0.0000e+00 1.9350e-08 0.0000e+00 1.9355e-08 1.0000e-03
+ 1.9405e-08 1.0000e-03 1.9410e-08 0.0000e+00 1.9550e-08 0.0000e+00
+ 1.9555e-08 1.0000e-03 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00
+ 1.9750e-08 0.0000e+00 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03
+ 1.9810e-08 0.0000e+00 2.0150e-08 0.0000e+00 2.0155e-08 1.0000e-03
+ 2.0205e-08 1.0000e-03 2.0210e-08 0.0000e+00 2.0350e-08 0.0000e+00
+ 2.0355e-08 1.0000e-03 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00
+ 2.0550e-08 0.0000e+00 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03
+ 2.0610e-08 0.0000e+00 2.0950e-08 0.0000e+00 2.0955e-08 1.0000e-03
+ 2.1005e-08 1.0000e-03 2.1010e-08 0.0000e+00 2.1150e-08 0.0000e+00
+ 2.1155e-08 1.0000e-03 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00
+ 2.1350e-08 0.0000e+00 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03
+ 2.1410e-08 0.0000e+00 2.1750e-08 0.0000e+00 2.1755e-08 1.0000e-03
+ 2.1805e-08 1.0000e-03 2.1810e-08 0.0000e+00 2.1950e-08 0.0000e+00
+ 2.1955e-08 1.0000e-03 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN6 0 IIN6x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 9.5000e-10 0.0000e+00
+ 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03 1.0100e-09 0.0000e+00
+ 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03 1.2050e-09 1.0000e-03
+ 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00 1.3550e-09 1.0000e-03
+ 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00 1.9500e-09 0.0000e+00
+ 1.9550e-09 1.0000e-03 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00
+ 2.1500e-09 0.0000e+00 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03
+ 2.2100e-09 0.0000e+00 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03
+ 2.4050e-09 1.0000e-03 2.4100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.9500e-09 0.0000e+00
+ 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03 4.0100e-09 0.0000e+00
+ 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03 4.2050e-09 1.0000e-03
+ 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00 4.3550e-09 1.0000e-03
+ 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00 4.9500e-09 0.0000e+00
+ 4.9550e-09 1.0000e-03 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00
+ 5.1500e-09 0.0000e+00 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03
+ 5.2100e-09 0.0000e+00 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03
+ 5.4050e-09 1.0000e-03 5.4100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.9500e-09 0.0000e+00
+ 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03 7.0100e-09 0.0000e+00
+ 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03 7.2050e-09 1.0000e-03
+ 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00 7.3550e-09 1.0000e-03
+ 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00 7.9500e-09 0.0000e+00
+ 7.9550e-09 1.0000e-03 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00
+ 8.1500e-09 0.0000e+00 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03
+ 8.2100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03 9.6050e-09 1.0000e-03
+ 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00 9.7550e-09 1.0000e-03
+ 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00 1.0350e-08 0.0000e+00
+ 1.0355e-08 1.0000e-03 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00
+ 1.0550e-08 0.0000e+00 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03
+ 1.0610e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03 1.2005e-08 1.0000e-03
+ 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00 1.2155e-08 1.0000e-03
+ 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00 1.2350e-08 0.0000e+00
+ 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03 1.2410e-08 0.0000e+00
+ 1.2950e-08 0.0000e+00 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03
+ 1.3010e-08 0.0000e+00 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03
+ 1.3205e-08 1.0000e-03 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00
+ 1.3355e-08 1.0000e-03 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03 1.5005e-08 1.0000e-03
+ 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00 1.5155e-08 1.0000e-03
+ 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00 1.5350e-08 0.0000e+00
+ 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03 1.5410e-08 0.0000e+00
+ 1.5950e-08 0.0000e+00 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03
+ 1.6010e-08 0.0000e+00 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03
+ 1.6205e-08 1.0000e-03 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00
+ 1.6355e-08 1.0000e-03 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03 1.8005e-08 1.0000e-03
+ 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00 1.8155e-08 1.0000e-03
+ 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00 1.8350e-08 0.0000e+00
+ 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03 1.8410e-08 0.0000e+00
+ 1.8950e-08 0.0000e+00 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03
+ 1.9010e-08 0.0000e+00 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03
+ 1.9205e-08 1.0000e-03 1.9210e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0550e-08 0.0000e+00 2.0555e-08 1.0000e-03
+ 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00 2.0750e-08 0.0000e+00
+ 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03 2.0810e-08 0.0000e+00
+ 2.1350e-08 0.0000e+00 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03
+ 2.1410e-08 0.0000e+00 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03
+ 2.1605e-08 1.0000e-03 2.1610e-08 0.0000e+00)
IIN7 0 IIN7x  PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00
+ 1.3550e-09 1.0000e-03 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03
+ 2.4100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00
+ 4.3550e-09 1.0000e-03 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03
+ 5.4100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00
+ 7.3550e-09 1.0000e-03 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.1500e-09 0.0000e+00
+ 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00
+ 9.7550e-09 1.0000e-03 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0550e-08 0.0000e+00
+ 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2350e-08 0.0000e+00 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03
+ 1.2410e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03
+ 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5350e-08 0.0000e+00 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03
+ 1.5410e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03
+ 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8350e-08 0.0000e+00 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03
+ 1.8410e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03
+ 1.9210e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0750e-08 0.0000e+00 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03
+ 2.0810e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03
+ 2.1610e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN8 0 IIN8x  PWL(0 0 20P 0 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03 4.0500e-10 1.0000e-03
+ 4.1000e-10 0.0000e+00 5.5000e-10 0.0000e+00 5.5500e-10 0.0000e+00
+ 6.0500e-10 0.0000e+00 6.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.3500e-09 0.0000e+00 1.3550e-09 1.0000e-03
+ 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00 1.5500e-09 0.0000e+00
+ 1.5550e-09 0.0000e+00 1.6050e-09 0.0000e+00 1.6100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.3500e-09 0.0000e+00
+ 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03 2.4100e-09 0.0000e+00
+ 2.5500e-09 0.0000e+00 2.5550e-09 0.0000e+00 2.6050e-09 0.0000e+00
+ 2.6100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03 3.4050e-09 1.0000e-03
+ 3.4100e-09 0.0000e+00 3.5500e-09 0.0000e+00 3.5550e-09 0.0000e+00
+ 3.6050e-09 0.0000e+00 3.6100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.3500e-09 0.0000e+00 4.3550e-09 1.0000e-03
+ 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00 4.5500e-09 0.0000e+00
+ 4.5550e-09 0.0000e+00 4.6050e-09 0.0000e+00 4.6100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.3500e-09 0.0000e+00
+ 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03 5.4100e-09 0.0000e+00
+ 5.5500e-09 0.0000e+00 5.5550e-09 0.0000e+00 5.6050e-09 0.0000e+00
+ 5.6100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03 6.4050e-09 1.0000e-03
+ 6.4100e-09 0.0000e+00 6.5500e-09 0.0000e+00 6.5550e-09 0.0000e+00
+ 6.6050e-09 0.0000e+00 6.6100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.3500e-09 0.0000e+00 7.3550e-09 1.0000e-03
+ 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00 7.5500e-09 0.0000e+00
+ 7.5550e-09 0.0000e+00 7.6050e-09 0.0000e+00 7.6100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 8.1500e-09 0.0000e+00 8.1550e-09 1.0000e-03
+ 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00 8.3500e-09 0.0000e+00
+ 8.3550e-09 0.0000e+00 8.4050e-09 0.0000e+00 8.4100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.9500e-09 0.0000e+00 8.9550e-09 1.0000e-03
+ 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00 9.1500e-09 0.0000e+00
+ 9.1550e-09 0.0000e+00 9.2050e-09 0.0000e+00 9.2100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.7500e-09 0.0000e+00 9.7550e-09 1.0000e-03
+ 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00 9.9500e-09 0.0000e+00
+ 9.9550e-09 0.0000e+00 1.0005e-08 0.0000e+00 1.0010e-08 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0550e-08 0.0000e+00 1.0555e-08 1.0000e-03
+ 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00 1.0750e-08 0.0000e+00
+ 1.0755e-08 0.0000e+00 1.0805e-08 0.0000e+00 1.0810e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1350e-08 0.0000e+00 1.1355e-08 1.0000e-03
+ 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00 1.1550e-08 0.0000e+00
+ 1.1555e-08 0.0000e+00 1.1605e-08 0.0000e+00 1.1610e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2350e-08 0.0000e+00
+ 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03 1.2410e-08 0.0000e+00
+ 1.2550e-08 0.0000e+00 1.2555e-08 0.0000e+00 1.2605e-08 0.0000e+00
+ 1.2610e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03 1.3405e-08 1.0000e-03
+ 1.3410e-08 0.0000e+00 1.3550e-08 0.0000e+00 1.3555e-08 0.0000e+00
+ 1.3605e-08 0.0000e+00 1.3610e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4350e-08 0.0000e+00 1.4355e-08 1.0000e-03
+ 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00 1.4550e-08 0.0000e+00
+ 1.4555e-08 0.0000e+00 1.4605e-08 0.0000e+00 1.4610e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5350e-08 0.0000e+00
+ 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03 1.5410e-08 0.0000e+00
+ 1.5550e-08 0.0000e+00 1.5555e-08 0.0000e+00 1.5605e-08 0.0000e+00
+ 1.5610e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03 1.6405e-08 1.0000e-03
+ 1.6410e-08 0.0000e+00 1.6550e-08 0.0000e+00 1.6555e-08 0.0000e+00
+ 1.6605e-08 0.0000e+00 1.6610e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7350e-08 0.0000e+00 1.7355e-08 1.0000e-03
+ 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00 1.7550e-08 0.0000e+00
+ 1.7555e-08 0.0000e+00 1.7605e-08 0.0000e+00 1.7610e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8350e-08 0.0000e+00
+ 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03 1.8410e-08 0.0000e+00
+ 1.8550e-08 0.0000e+00 1.8555e-08 0.0000e+00 1.8605e-08 0.0000e+00
+ 1.8610e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.9150e-08 0.0000e+00
+ 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03 1.9210e-08 0.0000e+00
+ 1.9350e-08 0.0000e+00 1.9355e-08 0.0000e+00 1.9405e-08 0.0000e+00
+ 1.9410e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9950e-08 0.0000e+00
+ 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03 2.0010e-08 0.0000e+00
+ 2.0150e-08 0.0000e+00 2.0155e-08 0.0000e+00 2.0205e-08 0.0000e+00
+ 2.0210e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0750e-08 0.0000e+00
+ 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03 2.0810e-08 0.0000e+00
+ 2.0950e-08 0.0000e+00 2.0955e-08 0.0000e+00 2.1005e-08 0.0000e+00
+ 2.1010e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1550e-08 0.0000e+00
+ 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03 2.1610e-08 0.0000e+00
+ 2.1750e-08 0.0000e+00 2.1755e-08 0.0000e+00 2.1805e-08 0.0000e+00
+ 2.1810e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
IIN9 0 IIN9x PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 3.5000e-10 0.0000e+00 3.5500e-10 1.0000e-03
+ 4.0500e-10 1.0000e-03 4.1000e-10 0.0000e+00 7.5000e-10 0.0000e+00
+ 7.5500e-10 1.0000e-03 8.0500e-10 1.0000e-03 8.1000e-10 0.0000e+00
+ 9.5000e-10 0.0000e+00 9.5500e-10 1.0000e-03 1.0050e-09 1.0000e-03
+ 1.0100e-09 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 1.3500e-09 0.0000e+00
+ 1.3550e-09 1.0000e-03 1.4050e-09 1.0000e-03 1.4100e-09 0.0000e+00
+ 1.7500e-09 0.0000e+00 1.7550e-09 1.0000e-03 1.8050e-09 1.0000e-03
+ 1.8100e-09 0.0000e+00 1.9500e-09 0.0000e+00 1.9550e-09 1.0000e-03
+ 2.0050e-09 1.0000e-03 2.0100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 2.3500e-09 0.0000e+00 2.3550e-09 1.0000e-03 2.4050e-09 1.0000e-03
+ 2.4100e-09 0.0000e+00 2.7500e-09 0.0000e+00 2.7550e-09 1.0000e-03
+ 2.8050e-09 1.0000e-03 2.8100e-09 0.0000e+00 2.9500e-09 0.0000e+00
+ 2.9550e-09 1.0000e-03 3.0050e-09 1.0000e-03 3.0100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 3.3500e-09 0.0000e+00 3.3550e-09 1.0000e-03
+ 3.4050e-09 1.0000e-03 3.4100e-09 0.0000e+00 3.7500e-09 0.0000e+00
+ 3.7550e-09 1.0000e-03 3.8050e-09 1.0000e-03 3.8100e-09 0.0000e+00
+ 3.9500e-09 0.0000e+00 3.9550e-09 1.0000e-03 4.0050e-09 1.0000e-03
+ 4.0100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 4.3500e-09 0.0000e+00
+ 4.3550e-09 1.0000e-03 4.4050e-09 1.0000e-03 4.4100e-09 0.0000e+00
+ 4.7500e-09 0.0000e+00 4.7550e-09 1.0000e-03 4.8050e-09 1.0000e-03
+ 4.8100e-09 0.0000e+00 4.9500e-09 0.0000e+00 4.9550e-09 1.0000e-03
+ 5.0050e-09 1.0000e-03 5.0100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 5.3500e-09 0.0000e+00 5.3550e-09 1.0000e-03 5.4050e-09 1.0000e-03
+ 5.4100e-09 0.0000e+00 5.7500e-09 0.0000e+00 5.7550e-09 1.0000e-03
+ 5.8050e-09 1.0000e-03 5.8100e-09 0.0000e+00 5.9500e-09 0.0000e+00
+ 5.9550e-09 1.0000e-03 6.0050e-09 1.0000e-03 6.0100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 6.3500e-09 0.0000e+00 6.3550e-09 1.0000e-03
+ 6.4050e-09 1.0000e-03 6.4100e-09 0.0000e+00 6.7500e-09 0.0000e+00
+ 6.7550e-09 1.0000e-03 6.8050e-09 1.0000e-03 6.8100e-09 0.0000e+00
+ 6.9500e-09 0.0000e+00 6.9550e-09 1.0000e-03 7.0050e-09 1.0000e-03
+ 7.0100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.3500e-09 0.0000e+00
+ 7.3550e-09 1.0000e-03 7.4050e-09 1.0000e-03 7.4100e-09 0.0000e+00
+ 7.7500e-09 0.0000e+00 7.7550e-09 1.0000e-03 7.8050e-09 1.0000e-03
+ 7.8100e-09 0.0000e+00 7.9500e-09 0.0000e+00 7.9550e-09 1.0000e-03
+ 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00 8.1500e-09 0.0000e+00
+ 8.1550e-09 1.0000e-03 8.2050e-09 1.0000e-03 8.2100e-09 0.0000e+00
+ 8.5500e-09 0.0000e+00 8.5550e-09 1.0000e-03 8.6050e-09 1.0000e-03
+ 8.6100e-09 0.0000e+00 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03
+ 8.8050e-09 1.0000e-03 8.8100e-09 0.0000e+00 8.9500e-09 0.0000e+00
+ 8.9550e-09 1.0000e-03 9.0050e-09 1.0000e-03 9.0100e-09 0.0000e+00
+ 9.3500e-09 0.0000e+00 9.3550e-09 1.0000e-03 9.4050e-09 1.0000e-03
+ 9.4100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 9.7500e-09 0.0000e+00
+ 9.7550e-09 1.0000e-03 9.8050e-09 1.0000e-03 9.8100e-09 0.0000e+00
+ 1.0150e-08 0.0000e+00 1.0155e-08 1.0000e-03 1.0205e-08 1.0000e-03
+ 1.0210e-08 0.0000e+00 1.0350e-08 0.0000e+00 1.0355e-08 1.0000e-03
+ 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00 1.0550e-08 0.0000e+00
+ 1.0555e-08 1.0000e-03 1.0605e-08 1.0000e-03 1.0610e-08 0.0000e+00
+ 1.0950e-08 0.0000e+00 1.0955e-08 1.0000e-03 1.1005e-08 1.0000e-03
+ 1.1010e-08 0.0000e+00 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03
+ 1.1205e-08 1.0000e-03 1.1210e-08 0.0000e+00 1.1350e-08 0.0000e+00
+ 1.1355e-08 1.0000e-03 1.1405e-08 1.0000e-03 1.1410e-08 0.0000e+00
+ 1.1750e-08 0.0000e+00 1.1755e-08 1.0000e-03 1.1805e-08 1.0000e-03
+ 1.1810e-08 0.0000e+00 1.1950e-08 0.0000e+00 1.1955e-08 1.0000e-03
+ 1.2005e-08 1.0000e-03 1.2010e-08 0.0000e+00 1.2150e-08 0.0000e+00
+ 1.2155e-08 1.0000e-03 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00
+ 1.2350e-08 0.0000e+00 1.2355e-08 1.0000e-03 1.2405e-08 1.0000e-03
+ 1.2410e-08 0.0000e+00 1.2750e-08 0.0000e+00 1.2755e-08 1.0000e-03
+ 1.2805e-08 1.0000e-03 1.2810e-08 0.0000e+00 1.2950e-08 0.0000e+00
+ 1.2955e-08 1.0000e-03 1.3005e-08 1.0000e-03 1.3010e-08 0.0000e+00
+ 1.3150e-08 0.0000e+00 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03
+ 1.3210e-08 0.0000e+00 1.3350e-08 0.0000e+00 1.3355e-08 1.0000e-03
+ 1.3405e-08 1.0000e-03 1.3410e-08 0.0000e+00 1.3750e-08 0.0000e+00
+ 1.3755e-08 1.0000e-03 1.3805e-08 1.0000e-03 1.3810e-08 0.0000e+00
+ 1.3950e-08 0.0000e+00 1.3955e-08 1.0000e-03 1.4005e-08 1.0000e-03
+ 1.4010e-08 0.0000e+00 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03
+ 1.4205e-08 1.0000e-03 1.4210e-08 0.0000e+00 1.4350e-08 0.0000e+00
+ 1.4355e-08 1.0000e-03 1.4405e-08 1.0000e-03 1.4410e-08 0.0000e+00
+ 1.4750e-08 0.0000e+00 1.4755e-08 1.0000e-03 1.4805e-08 1.0000e-03
+ 1.4810e-08 0.0000e+00 1.4950e-08 0.0000e+00 1.4955e-08 1.0000e-03
+ 1.5005e-08 1.0000e-03 1.5010e-08 0.0000e+00 1.5150e-08 0.0000e+00
+ 1.5155e-08 1.0000e-03 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00
+ 1.5350e-08 0.0000e+00 1.5355e-08 1.0000e-03 1.5405e-08 1.0000e-03
+ 1.5410e-08 0.0000e+00 1.5750e-08 0.0000e+00 1.5755e-08 1.0000e-03
+ 1.5805e-08 1.0000e-03 1.5810e-08 0.0000e+00 1.5950e-08 0.0000e+00
+ 1.5955e-08 1.0000e-03 1.6005e-08 1.0000e-03 1.6010e-08 0.0000e+00
+ 1.6150e-08 0.0000e+00 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03
+ 1.6210e-08 0.0000e+00 1.6350e-08 0.0000e+00 1.6355e-08 1.0000e-03
+ 1.6405e-08 1.0000e-03 1.6410e-08 0.0000e+00 1.6750e-08 0.0000e+00
+ 1.6755e-08 1.0000e-03 1.6805e-08 1.0000e-03 1.6810e-08 0.0000e+00
+ 1.6950e-08 0.0000e+00 1.6955e-08 1.0000e-03 1.7005e-08 1.0000e-03
+ 1.7010e-08 0.0000e+00 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03
+ 1.7205e-08 1.0000e-03 1.7210e-08 0.0000e+00 1.7350e-08 0.0000e+00
+ 1.7355e-08 1.0000e-03 1.7405e-08 1.0000e-03 1.7410e-08 0.0000e+00
+ 1.7750e-08 0.0000e+00 1.7755e-08 1.0000e-03 1.7805e-08 1.0000e-03
+ 1.7810e-08 0.0000e+00 1.7950e-08 0.0000e+00 1.7955e-08 1.0000e-03
+ 1.8005e-08 1.0000e-03 1.8010e-08 0.0000e+00 1.8150e-08 0.0000e+00
+ 1.8155e-08 1.0000e-03 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00
+ 1.8350e-08 0.0000e+00 1.8355e-08 1.0000e-03 1.8405e-08 1.0000e-03
+ 1.8410e-08 0.0000e+00 1.8750e-08 0.0000e+00 1.8755e-08 1.0000e-03
+ 1.8805e-08 1.0000e-03 1.8810e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9150e-08 0.0000e+00 1.9155e-08 1.0000e-03 1.9205e-08 1.0000e-03
+ 1.9210e-08 0.0000e+00 1.9550e-08 0.0000e+00 1.9555e-08 1.0000e-03
+ 1.9605e-08 1.0000e-03 1.9610e-08 0.0000e+00 1.9750e-08 0.0000e+00
+ 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03 1.9810e-08 0.0000e+00
+ 1.9950e-08 0.0000e+00 1.9955e-08 1.0000e-03 2.0005e-08 1.0000e-03
+ 2.0010e-08 0.0000e+00 2.0350e-08 0.0000e+00 2.0355e-08 1.0000e-03
+ 2.0405e-08 1.0000e-03 2.0410e-08 0.0000e+00 2.0550e-08 0.0000e+00
+ 2.0555e-08 1.0000e-03 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00
+ 2.0750e-08 0.0000e+00 2.0755e-08 1.0000e-03 2.0805e-08 1.0000e-03
+ 2.0810e-08 0.0000e+00 2.1150e-08 0.0000e+00 2.1155e-08 1.0000e-03
+ 2.1205e-08 1.0000e-03 2.1210e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00
+ 2.1550e-08 0.0000e+00 2.1555e-08 1.0000e-03 2.1605e-08 1.0000e-03
+ 2.1610e-08 0.0000e+00 2.1950e-08 0.0000e+00 2.1955e-08 1.0000e-03
+ 2.2005e-08 1.0000e-03 2.2010e-08 0.0000e+00)
LIN1 IIN1x IN1 1p
LIN2 IIN2x IN2 1p
LIN3 IIN3x IN3 1p
LIN4 IIN4x IN4 1p
LIN5 IIN5x IN5 1p
LIN6 IIN6x IN6 1p
LIN7 IIN7x IN7 1p
LIN8 IIN8x IN8 1p
LIN9 IIN9x IN9 1p
ITARGETA 0 TARGETA PWL(0 0 20P 0 1.5000e-10 0.0000e+00 1.5500e-10 1.0000e-03 2.0500e-10 1.0000e-03
+ 2.1000e-10 0.0000e+00 1.1500e-09 0.0000e+00 1.1550e-09 1.0000e-03
+ 1.2050e-09 1.0000e-03 1.2100e-09 0.0000e+00 2.1500e-09 0.0000e+00
+ 2.1550e-09 1.0000e-03 2.2050e-09 1.0000e-03 2.2100e-09 0.0000e+00
+ 3.1500e-09 0.0000e+00 3.1550e-09 1.0000e-03 3.2050e-09 1.0000e-03
+ 3.2100e-09 0.0000e+00 4.1500e-09 0.0000e+00 4.1550e-09 1.0000e-03
+ 4.2050e-09 1.0000e-03 4.2100e-09 0.0000e+00 5.1500e-09 0.0000e+00
+ 5.1550e-09 1.0000e-03 5.2050e-09 1.0000e-03 5.2100e-09 0.0000e+00
+ 6.1500e-09 0.0000e+00 6.1550e-09 1.0000e-03 6.2050e-09 1.0000e-03
+ 6.2100e-09 0.0000e+00 7.1500e-09 0.0000e+00 7.1550e-09 1.0000e-03
+ 7.2050e-09 1.0000e-03 7.2100e-09 0.0000e+00 7.9500e-09 0.0000e+00
+ 7.9550e-09 1.0000e-03 8.0050e-09 1.0000e-03 8.0100e-09 0.0000e+00
+ 8.7500e-09 0.0000e+00 8.7550e-09 1.0000e-03 8.8050e-09 1.0000e-03
+ 8.8100e-09 0.0000e+00 9.5500e-09 0.0000e+00 9.5550e-09 1.0000e-03
+ 9.6050e-09 1.0000e-03 9.6100e-09 0.0000e+00 1.0350e-08 0.0000e+00
+ 1.0355e-08 1.0000e-03 1.0405e-08 1.0000e-03 1.0410e-08 0.0000e+00
+ 1.1150e-08 0.0000e+00 1.1155e-08 1.0000e-03 1.1205e-08 1.0000e-03
+ 1.1210e-08 0.0000e+00 1.2150e-08 0.0000e+00 1.2155e-08 1.0000e-03
+ 1.2205e-08 1.0000e-03 1.2210e-08 0.0000e+00 1.3150e-08 0.0000e+00
+ 1.3155e-08 1.0000e-03 1.3205e-08 1.0000e-03 1.3210e-08 0.0000e+00
+ 1.4150e-08 0.0000e+00 1.4155e-08 1.0000e-03 1.4205e-08 1.0000e-03
+ 1.4210e-08 0.0000e+00 1.5150e-08 0.0000e+00 1.5155e-08 1.0000e-03
+ 1.5205e-08 1.0000e-03 1.5210e-08 0.0000e+00 1.6150e-08 0.0000e+00
+ 1.6155e-08 1.0000e-03 1.6205e-08 1.0000e-03 1.6210e-08 0.0000e+00
+ 1.7150e-08 0.0000e+00 1.7155e-08 1.0000e-03 1.7205e-08 1.0000e-03
+ 1.7210e-08 0.0000e+00 1.8150e-08 0.0000e+00 1.8155e-08 1.0000e-03
+ 1.8205e-08 1.0000e-03 1.8210e-08 0.0000e+00 1.8950e-08 0.0000e+00
+ 1.8955e-08 1.0000e-03 1.9005e-08 1.0000e-03 1.9010e-08 0.0000e+00
+ 1.9750e-08 0.0000e+00 1.9755e-08 1.0000e-03 1.9805e-08 1.0000e-03
+ 1.9810e-08 0.0000e+00 2.0550e-08 0.0000e+00 2.0555e-08 1.0000e-03
+ 2.0605e-08 1.0000e-03 2.0610e-08 0.0000e+00 2.1350e-08 0.0000e+00
+ 2.1355e-08 1.0000e-03 2.1405e-08 1.0000e-03 2.1410e-08 0.0000e+00)
IINBIAS1 0 INB01 pulse(0 1m 150p 5p 5p 50p 200p)
LINBIAS1 INB01 INB1 1p
***   SETUP ***
VAC1   A1   0   SIN(0 723mV 10GHz 200ps 0)
RAC1   A1   A2   1000
LAC1   A2   A3   0.1p
VAC2   B1   0   SIN(0 723mV 10GHz 175.0ps 0)
RAC2   B1   B2   1000
LAC2   B2   B3   0.1p
VDC    DC1   0   pwl(0 0 20p 1023mV)
RDC    DC1   DC2   1000
LDC    DC2   DC3  0.1p
VDCconv    DCc1   0   PWL(0ps 0mV 20ps 1023mV 1280000ps 1023mV 1280001ps 0)
RDCconv    DCc1   DCc2  750
LDCconv    DCc2   DCc3   0.1p
***   INITIALIZE ***
IINITIAL1 0 INITIAL1 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL2 0 INITIAL2 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL3 0 INITIAL3 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL4 0 INITIAL4 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL5 0 INITIAL5 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL6 0 INITIAL6 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL7 0 INITIAL7 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL8 0 INITIAL8 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
IINITIAL9 0 INITIAL9 PWL(0 0 20P 0*-2*22.6u 2500000p 0*-2*22.6u 2500000p 0)
Iconst1 0 CONSTIN1 PWL(0 0 20P  40U )
IINITIALB1 0 INITIALB1 PWL(0 0 20P 0*-22.6u 2500000p 0*-22.6u 2500000p 0)
***   NEURONS ***
X1 NEURONLETTER IN1 IN2 IN3 IN4 IN5 IN6 IN7 IN8 IN9 INB1          TARGETA INITIAL1 INITIAL2 INITIAL3 INITIAL4 INITIAL5 INITIAL6 INITIAL7 INITIAL8 INITIAL9 INITIALB1           A3 0 B3 0 DC3 0 DCc3 0 CONSTIN1
***   CONTROLS ***
.print devi LIN1
.print devi LIN2
.print devi LIN3
.print devi LIN4
.print devi LIN5
.print devi LIN6
.print devi LIN7
.print devi LIN8
.print devi LIN9
.print phase L1_q.xincr.xperceptron12.x1
.print phase L2_q.xincr.xperceptron12.x1
.print phase L4_q.xincr.xperceptron12.x1
.print phase L5_q.xincr.xperceptron12.x1
.print devi ITARGETA
.print phase LQ.XCOMP.X1
.print devi ITARGETU
.print phase LSTORE1.XSYN1.X1
.print phase LSTORE1.XSYN2.X1
.print phase LSTORE1.XSYN3.X1
.print phase LSTORE1.XSYN4.X1
